qtdeclarative.bbappend:

ALLOW_EMPTY_${PN}-plugins = "1"
